options:
  parameters:
    author: Adiyabat]
    description: Contactless HR/RR vital-sign sensing using a USRP B205mini as a CW Doppler radar
    generate_options: qt_gui
    id: heart_resp_radar_b205mini
    output_language: python
    title: Heart Rate and Respiration CW Doppler Radar (B205mini)
  states: {}

blocks:
- name: decim1
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: decim2
  id: variable
  parameters:
    value: '50'
  states: {}
- name: hr_high
  id: variable
  parameters:
    value: '3.3'
  states: {}
- name: hr_low
  id: variable
  parameters:
    value: '0.8'
  states: {}
- name: min_amplitude
  id: variable_qtgui_range
  parameters:
    label: '"Min Amplitude (rad, gate)"'
    start: '0.0'
    step: '0.005'
    stop: '1.0'
    value: '0.05'
  states: {}
- name: rate1
  id: variable
  parameters:
    value: samp_rate/decim1
  states: {}
- name: rate2
  id: variable
  parameters:
    value: rate1/decim2
  states: {}
- name: resp_high
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: resp_low
  id: variable
  parameters:
    value: '0.1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: snr_ratio
  id: variable_qtgui_range
  parameters:
    label: '"SNR Ratio (gate)"'
    start: '1.0'
    step: '0.5'
    stop: '20.0'
    value: '8.0'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: complex
  states: {}
- name: bpf_hr
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: hr_high
    low_cutoff_freq: hr_low
    samp_rate: rate2
    type: fir_filter_fff
    width: '0.3'
    win: window.WIN_HAMMING
  states: {}
- name: bpf_resp
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: resp_high
    low_cutoff_freq: resp_low
    samp_rate: rate2
    type: fir_filter_fff
    width: '0.05'
    win: window.WIN_HAMMING
  states: {}
- name: clutter_cancel
  id: epy_block
  parameters:
    _source_code: |
      """
      Adaptive static-clutter (TX->RX leakage) canceller.

      A monostatic CW radar's received signal is dominated by a large, nearly
      static complex vector: the direct TX->RX leakage plus reflections off
      everything in the room that isn't moving. The tiny phase modulation
      caused by a chest moving a few millimeters rides on top of this as a
      small perturbation. If the static vector is much larger than the motion
      term, atan2() becomes very sensitive to ordinary receiver noise (the
      "chaotic phase, no matter what" symptom), because the noise now competes
      with a weak wanted signal instead of the strong static one.

      dc_blocker_xx already removes the pure-0 Hz component, but any leakage
      that drifts slowly (temperature, cable flex, DC offset creep) is not
      exactly 0 Hz and survives a fixed-length DC blocker. This block tracks
      that drift with a slow exponential moving average (EMA) and subtracts
      it every sample:

          avg[n] = avg[n-1] + alpha * (x[n] - avg[n-1])
          y[n]   = x[n] - avg[n-1]

      This is a one-pole high-pass filter with cutoff f_c ~= alpha * samp_rate
      / (2*pi). At this block's sample rate (rate2, ~20 Sps) the default
      alpha=0.01 gives f_c ~= 0.03 Hz, well below resp_low (0.1 Hz) -- so real
      breathing/heartbeat modulation passes through essentially unaffected,
      while slow static/near-static clutter is tracked and cancelled.

      Tuning: if respiration amplitude still looks suppressed, lower alpha
      (slower tracking, e.g. 0.005). If leakage drift still isn't fully
      removed, raise alpha (faster tracking, e.g. 0.02) -- but too high will
      start eating into the respiration band itself.
      """
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          """Slow-EMA clutter/leakage canceller (complex in -> complex out)"""

          def __init__(self, alpha=0.01):
              gr.sync_block.__init__(
                  self,
                  name='Clutter Canceller (slow EMA subtract)',
                  in_sig=[np.complex64],
                  out_sig=[np.complex64],
              )
              self.alpha = alpha
              self.avg = None

          def work(self, input_items, output_items):
              x = input_items[0]
              n = len(x)
              if self.avg is None:
                  self.avg = x[0]
              avg = self.avg
              alpha = self.alpha
              out = np.empty(n, dtype=np.complex64)
              for i in range(n):
                  out[i] = x[i] - avg
                  avg = avg + alpha * (x[i] - avg)
              self.avg = avg
              output_items[0][:] = out
              return n
    alpha: '0.03'
  states: {}
- name: dc_block
  id: dc_blocker_xx
  parameters:
    length: '128'
    long_form: 'True'
    type: cc
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '5'
    decim: '1'
    gain: '1'
    samp_rate: rate1
    type: fir_filter_ccf
    width: '2'
    win: window.WIN_HAMMING
  states: {}
- name: lpf1
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: decim1
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: num_hr_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '220'
    min: '0'
    name: '"Heart rate (beats/min)"'
    type: float
  states: {}
- name: num_resp_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '40'
    min: '0'
    name: '"Respiration rate (breaths/min)"'
    type: float
  states: {}
- name: phase
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '20'
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: '20'
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_2
  id: qtgui_freq_sink_x
  parameters:
    bw: '20'
    fc: '0'
    fftsize: '1024'
    name: Resp Freq
    type: float
  states: {}
- name: qtgui_freq_sink_x_3
  id: qtgui_freq_sink_x
  parameters:
    bw: '20'
    fc: '0'
    fftsize: '1024'
    name: '"Heart rate in freq"'
    type: float
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: 1e3
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: rate2
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: '20'
    type: float
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: '20'
    type: float
  states: {}
- name: qtgui_time_sink_x_3
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: '20'
    type: float
  states: {}
- name: rate_est_hr
  id: epy_block
  parameters:
    _source_code: |
      """
      Peak-frequency rate estimator with a two-part signal-validity gate.

      Reports the strongest FFT peak inside [f_low, f_high] Hz (in events per
      minute) from a sliding window of the band-passed phase signal -- but
      ONLY when that peak looks like a real, sustained periodic signal, not
      colored noise left over from integrating (unwrapping) receiver/leakage
      noise. Two gates must both pass:

      1. Amplitude gate: windowed signal's std must exceed `min_amplitude`.
      2. In-band SNR gate + frequency-stability gate: the peak must stand
         out `snr_ratio`x above the median of the OTHER bins in the same
         band (a locally-fair noise-floor estimate, robust to the 1/f^2
         coloring that comes from phase-unwrap integrating noise -- a global
         full-spectrum median is not fair, since it compares against much
         quieter high-frequency bins). AND that peak's frequency must stay
         within `stability_tol` (relative) of itself across the last
         `stability_count` consecutive accepted windows -- a real
         breathing/heartbeat rate holds steady for several seconds in a row;
         a colored-noise peak wanders window to window.

      When any gate fails, the block reports 0.0 (not the last good value)
      and clears its stability history, so a live BPM readout of 0 clearly
      means "no valid, sustained rate detected."

      Tuning: watch this block's readout with no one in front of the radar.
      If it isn't reliably 0, raise `snr_ratio` and/or `stability_count`
      (fewer false positives, slower to lock on) or raise `min_amplitude` if
      the empty-room signal amplitude is high. If it's reliably 0 but real
      breathing/heartbeat also reads 0, lower these -- there's a real
      sensitivity/false-negative tradeoff; better TX/RX antenna isolation
      (reducing the underlying leakage-driven noise) helps both sides of it.
      """
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          """Windowed-FFT peak-rate estimator with amplitude + local-SNR +
          frequency-stability gating (float in -> float BPM out)"""

          def __init__(self, samp_rate=20.0, f_low=0.1, f_high=0.5,
                       window_sec=15.0, update_sec=1.0,
                       min_amplitude=0.05, snr_ratio=8.0,
                       stability_count=5, stability_tol=0.15):
              gr.sync_block.__init__(
                  self,
                  name='Rate Estimator (BPM)',
                  in_sig=[np.float32],
                  out_sig=[np.float32],
              )
              self.samp_rate = samp_rate
              self.f_low = f_low
              self.f_high = f_high
              self.window_len = max(int(window_sec * samp_rate), 8)
              self.update_len = max(int(update_sec * samp_rate), 1)
              self.min_amplitude = min_amplitude
              self.snr_ratio = snr_ratio
              self.stability_count = max(int(stability_count), 1)
              self.stability_tol = stability_tol
              self.buf = np.zeros(self.window_len, dtype=np.float64)
              self.filled = 0
              self.since_update = 0
              self.bpm = 0.0
              self.recent_freqs = []

          def work(self, input_items, output_items):
              x = input_items[0]
              n = len(x)
              for i in range(n):
                  self.buf[:-1] = self.buf[1:]
                  self.buf[-1] = x[i]
                  if self.filled < self.window_len:
                      self.filled += 1
                  self.since_update += 1
                  if (self.since_update >= self.update_len
                          and self.filled >= self.window_len // 2):
                      self._update_bpm()
                      self.since_update = 0
                  output_items[0][i] = self.bpm
              return n

          def _update_bpm(self):
              seg = self.buf[-self.filled:]
              seg = seg - np.mean(seg)

              # Gate 1: is anything actually moving?
              if np.std(seg) < self.min_amplitude:
                  self.recent_freqs = []
                  self.bpm = 0.0
                  return

              win = np.hanning(len(seg))
              spec = np.abs(np.fft.rfft(seg * win))
              freqs = np.fft.rfftfreq(len(seg), d=1.0 / self.samp_rate)
              mask = (freqs >= self.f_low) & (freqs <= self.f_high)
              if not np.any(mask):
                  self.recent_freqs = []
                  self.bpm = 0.0
                  return

              band_mag = spec[mask]
              band_freqs = freqs[mask]
              peak_idx = np.argmax(band_mag)
              peak_mag = band_mag[peak_idx]

              # Gate 2: local (in-band) SNR -- fair even if the overall
              # spectrum is colored (e.g. 1/f^2 from phase-unwrap noise).
              other_bins = np.delete(band_mag, peak_idx)
              noise_floor = (np.median(other_bins) if len(other_bins) else 0.0) + 1e-12
              if peak_mag < self.snr_ratio * noise_floor:
                  self.recent_freqs = []
                  self.bpm = 0.0
                  return

              peak_freq = band_freqs[peak_idx]

              # Gate 3: frequency stability across consecutive windows -- a
              # real periodic signal holds its frequency; a wandering
              # colored-noise peak does not.
              self.recent_freqs.append(peak_freq)
              if len(self.recent_freqs) > self.stability_count:
                  self.recent_freqs.pop(0)
              if len(self.recent_freqs) < self.stability_count:
                  self.bpm = 0.0
                  return
              lo, hi = min(self.recent_freqs), max(self.recent_freqs)
              center = float(np.mean(self.recent_freqs))
              if (hi - lo) > self.stability_tol * center:
                  self.bpm = 0.0
                  return

              self.bpm = center * 60.0
    f_high: hr_high
    f_low: hr_low
    min_amplitude: min_amplitude
    samp_rate: rate2
    snr_ratio: snr_ratio
    stability_count: '5'
    stability_tol: '0.15'
    update_sec: '1.0'
    window_sec: '10.0'
  states: {}
- name: rate_est_resp
  id: epy_block
  parameters:
    _source_code: |
      """
      Peak-frequency rate estimator with a two-part signal-validity gate.

      Reports the strongest FFT peak inside [f_low, f_high] Hz (in events per
      minute) from a sliding window of the band-passed phase signal -- but
      ONLY when that peak looks like a real, sustained periodic signal, not
      colored noise left over from integrating (unwrapping) receiver/leakage
      noise. Two gates must both pass:

      1. Amplitude gate: windowed signal's std must exceed `min_amplitude`.
      2. In-band SNR gate + frequency-stability gate: the peak must stand
         out `snr_ratio`x above the median of the OTHER bins in the same
         band (a locally-fair noise-floor estimate, robust to the 1/f^2
         coloring that comes from phase-unwrap integrating noise -- a global
         full-spectrum median is not fair, since it compares against much
         quieter high-frequency bins). AND that peak's frequency must stay
         within `stability_tol` (relative) of itself across the last
         `stability_count` consecutive accepted windows -- a real
         breathing/heartbeat rate holds steady for several seconds in a row;
         a colored-noise peak wanders window to window.

      When any gate fails, the block reports 0.0 (not the last good value)
      and clears its stability history, so a live BPM readout of 0 clearly
      means "no valid, sustained rate detected."

      Tuning: watch this block's readout with no one in front of the radar.
      If it isn't reliably 0, raise `snr_ratio` and/or `stability_count`
      (fewer false positives, slower to lock on) or raise `min_amplitude` if
      the empty-room signal amplitude is high. If it's reliably 0 but real
      breathing/heartbeat also reads 0, lower these -- there's a real
      sensitivity/false-negative tradeoff; better TX/RX antenna isolation
      (reducing the underlying leakage-driven noise) helps both sides of it.
      """
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          """Windowed-FFT peak-rate estimator with amplitude + local-SNR +
          frequency-stability gating (float in -> float BPM out)"""

          def __init__(self, samp_rate=20.0, f_low=0.1, f_high=0.5,
                       window_sec=15.0, update_sec=1.0,
                       min_amplitude=0.05, snr_ratio=8.0,
                       stability_count=5, stability_tol=0.15):
              gr.sync_block.__init__(
                  self,
                  name='Rate Estimator (BPM)',
                  in_sig=[np.float32],
                  out_sig=[np.float32],
              )
              self.samp_rate = samp_rate
              self.f_low = f_low
              self.f_high = f_high
              self.window_len = max(int(window_sec * samp_rate), 8)
              self.update_len = max(int(update_sec * samp_rate), 1)
              self.min_amplitude = min_amplitude
              self.snr_ratio = snr_ratio
              self.stability_count = max(int(stability_count), 1)
              self.stability_tol = stability_tol
              self.buf = np.zeros(self.window_len, dtype=np.float64)
              self.filled = 0
              self.since_update = 0
              self.bpm = 0.0
              self.recent_freqs = []

          def work(self, input_items, output_items):
              x = input_items[0]
              n = len(x)
              for i in range(n):
                  self.buf[:-1] = self.buf[1:]
                  self.buf[-1] = x[i]
                  if self.filled < self.window_len:
                      self.filled += 1
                  self.since_update += 1
                  if (self.since_update >= self.update_len
                          and self.filled >= self.window_len // 2):
                      self._update_bpm()
                      self.since_update = 0
                  output_items[0][i] = self.bpm
              return n

          def _update_bpm(self):
              seg = self.buf[-self.filled:]
              seg = seg - np.mean(seg)

              # Gate 1: is anything actually moving?
              if np.std(seg) < self.min_amplitude:
                  self.recent_freqs = []
                  self.bpm = 0.0
                  return

              win = np.hanning(len(seg))
              spec = np.abs(np.fft.rfft(seg * win))
              freqs = np.fft.rfftfreq(len(seg), d=1.0 / self.samp_rate)
              mask = (freqs >= self.f_low) & (freqs <= self.f_high)
              if not np.any(mask):
                  self.recent_freqs = []
                  self.bpm = 0.0
                  return

              band_mag = spec[mask]
              band_freqs = freqs[mask]
              peak_idx = np.argmax(band_mag)
              peak_mag = band_mag[peak_idx]

              # Gate 2: local (in-band) SNR -- fair even if the overall
              # spectrum is colored (e.g. 1/f^2 from phase-unwrap noise).
              other_bins = np.delete(band_mag, peak_idx)
              noise_floor = (np.median(other_bins) if len(other_bins) else 0.0) + 1e-12
              if peak_mag < self.snr_ratio * noise_floor:
                  self.recent_freqs = []
                  self.bpm = 0.0
                  return

              peak_freq = band_freqs[peak_idx]

              # Gate 3: frequency stability across consecutive windows -- a
              # real periodic signal holds its frequency; a wandering
              # colored-noise peak does not.
              self.recent_freqs.append(peak_freq)
              if len(self.recent_freqs) > self.stability_count:
                  self.recent_freqs.pop(0)
              if len(self.recent_freqs) < self.stability_count:
                  self.bpm = 0.0
                  return
              lo, hi = min(self.recent_freqs), max(self.recent_freqs)
              center = float(np.mean(self.recent_freqs))
              if (hi - lo) > self.stability_tol * center:
                  self.bpm = 0.0
                  return

              self.bpm = center * 60.0
    f_high: resp_high
    f_low: resp_low
    min_amplitude: min_amplitude
    samp_rate: rate2
    snr_ratio: snr_ratio
    stability_count: '5'
    stability_tol: '0.15'
    update_sec: '1.0'
    window_sec: '20.0'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: 5.53e9
    gain0: '40'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: 5.53e9
    gain0: '50'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: unwrap
  id: epy_block
  parameters:
    _source_code: |
      """
      Continuous phase unwrap.

      np.unwrap() only unwraps within a single call; this block keeps state
      across GNU Radio work() calls so the phase stays continuous across the
      whole stream (needed since the radar runs indefinitely).
      """
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          """Stateful phase unwrap (float radians in -> float radians out)"""

          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='Phase Unwrap (stateful)',
                  in_sig=[np.float32],
                  out_sig=[np.float32],
              )
              self.last_raw = None
              self.last_unwrapped = 0.0

          def work(self, input_items, output_items):
              x = input_items[0].astype(np.float64)
              n = len(x)
              if self.last_raw is None:
                  self.last_raw = x[0]
              prepended = np.concatenate(([self.last_raw], x))
              diffs = np.diff(prepended)
              wrapped = (diffs + np.pi) % (2 * np.pi) - np.pi
              out = self.last_unwrapped + np.cumsum(wrapped)
              self.last_raw = x[-1]
              self.last_unwrapped = out[-1]
              output_items[0][:] = out.astype(np.float32)
              return n
  states: {}

connections:
- [analog_const_source_x_0, '0', uhd_usrp_sink_0, '0']
- [bpf_hr, '0', qtgui_freq_sink_x_3, '0']
- [bpf_hr, '0', qtgui_time_sink_x_3, '0']
- [bpf_hr, '0', rate_est_hr, '0']
- [bpf_resp, '0', qtgui_freq_sink_x_2, '0']
- [bpf_resp, '0', qtgui_time_sink_x_2, '0']
- [bpf_resp, '0', rate_est_resp, '0']
- [clutter_cancel, '0', phase, '0']
- [clutter_cancel, '0', qtgui_freq_sink_x_1, '0']
- [dc_block, '0', lpf1, '0']
- [low_pass_filter_0, '0', clutter_cancel, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [lpf1, '0', low_pass_filter_0, '0']
- [lpf1, '0', qtgui_sink_x_0, '0']
- [phase, '0', qtgui_time_sink_x_0, '0']
- [phase, '0', unwrap, '0']
- [rate_est_hr, '0', num_hr_0, '0']
- [rate_est_resp, '0', num_resp_0, '0']
- [uhd_usrp_source_0, '0', dc_block, '0']
- [unwrap, '0', bpf_hr, '0']
- [unwrap, '0', bpf_resp, '0']
- [unwrap, '0', qtgui_time_sink_x_1, '0']

metadata:
  file_format: 1
